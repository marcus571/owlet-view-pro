## dts/bindings/zmk,behavior-screen-swap.yaml
```yaml
# dts/bindings/zmk,behavior-screen-swap.yaml
description: Screen swap behavior

compatible: "zmk,behavior-screen-swap"

properties: {}
```
